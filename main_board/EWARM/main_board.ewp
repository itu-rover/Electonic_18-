# IAR project main_board.ewp, settings and files
configuration main_board (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F091xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: main_board.out
  ILINK.IlinkIcfFile: stm32f091xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F0xx_HAL_Driver
    ./: 
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f0xx.c
  group Application
    ./: 
  group Application/EWARM
    ./:  startup_stm32f091xc.s
  group Application/User
    ./: 
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
