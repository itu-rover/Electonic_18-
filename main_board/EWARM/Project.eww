<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\main_board.ewp</path>
  </project>
  <batchBuild />
</workspace>
